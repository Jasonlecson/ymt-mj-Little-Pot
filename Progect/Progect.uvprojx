# Keil uVision project Progect.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Progect +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe  --bin -o  .\Progect\fw.bin  .\output\Progect.axf
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\inc;..\Libraries\src;..\Startup;..\User;..\MQTT;..\CMSIS;..\Mem
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0xcc00
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: stm32f10x_it.c main.c System.c delay.c include.h usart.c gpio.c cString.c key.c iwdg.c timer.c IAP.c stmflash.c ADC.c DMA.c parse.c FlashData.c TM601.c SmartConfig.c iic2.c pwm.c flash_helper.c AHT10_I2C.c BH1750.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group Libraries
    ../Libraries/src/: misc.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_adc.c
  group Startup
    ../Startup/: startup_stm32f10x_hd.s
  group Mem
    ../Mem/: BufferManage.c LoopList.c
